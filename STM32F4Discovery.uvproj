# Keil uVision project STM32F4Discovery.uvproj, settings and files
target STM32F4Discovery (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4Discovery
  c flags: Optim=1 wLevel=2
  c define: STM32F407VG,STM32F4XX,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .;.\CMSIS;.\Startup;.\ThirdParty;..\STM32F4xx_DSP_StdPeriph_Lib_V1.0.1\Libraries\CMSIS\Include;..\STM32F4xx_DSP_StdPeriph_Lib_V1.0.1\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\STM32F4xx_DSP_StdPeriph_Lib_V1.0.1\Libraries\STM32F4xx_StdPeriph_Driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./startup/: startup_stm32f40xx.s
    ./Startup/: system_stm32f4xx.c
  group CMSIS
    ./CMSIS/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group CMSIS-Lib
    ../STM32F4xx_DSP_StdPeriph_Lib_V1.0.1/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c
  group User
    ./: main.c
  group DiscoveryTools
    ./ThirdParty/: stm32f4_discovery.c
